* C:\Users\vansh\eSim-Workspace\3_bit_flash_ADC\3_bit_flash_ADC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 3/8/2022 1:20:19 AM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
X5  Net-_R12-Pad1_ Net-_R1-Pad2_ Vin Net-_X1-Pad4_ Net-_R12-Pad2_ Net-_U6-Pad1_ +VCC ? lm_741
X6  Net-_R13-Pad1_ Net-_R2-Pad2_ Vin Net-_X1-Pad4_ Net-_R13-Pad2_ Net-_U6-Pad2_ +VCC ? lm_741
X7  Net-_R14-Pad1_ Net-_R3-Pad2_ Vin Net-_X1-Pad4_ Net-_R14-Pad2_ Net-_U6-Pad3_ +VCC ? lm_741
X1  Net-_R15-Pad1_ Net-_R4-Pad2_ Vin Net-_X1-Pad4_ Net-_R15-Pad2_ Net-_U6-Pad4_ +VCC ? lm_741
X2  Net-_R16-Pad1_ Net-_R5-Pad2_ Vin Net-_X1-Pad4_ Net-_R16-Pad2_ Net-_U6-Pad5_ +VCC ? lm_741
X3  Net-_R17-Pad1_ Net-_R6-Pad2_ Vin Net-_X1-Pad4_ Net-_R17-Pad2_ Net-_U6-Pad6_ +VCC ? lm_741
X4  Net-_R18-Pad1_ Net-_R7-Pad2_ Vin Net-_X1-Pad4_ Net-_R18-Pad2_ Net-_U6-Pad8_ +VCC ? lm_741
R8  Net-_R7-Pad2_ GND 1k
R2  Net-_R1-Pad2_ Net-_R2-Pad2_ 1k
R3  Net-_R2-Pad2_ Net-_R3-Pad2_ 1k
R4  Net-_R3-Pad2_ Net-_R4-Pad2_ 1k
R5  Net-_R4-Pad2_ Net-_R5-Pad2_ 1k
R6  Net-_R5-Pad2_ Net-_R6-Pad2_ 1k
R7  Net-_R6-Pad2_ Net-_R7-Pad2_ 1k
U3  out2 plot_v1
U5  out1 plot_v1
U4  out0 plot_v1
v1  Vin GND sine
U1  Vin plot_v1
v2  +VCC GND 15
R1  Vref Net-_R1-Pad2_ 1k
U7  Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ Net-_R9-Pad1_ Net-_R10-Pad1_ Net-_R11-Pad1_ dac_bridge_3
X8  Net-_R19-Pad1_ GND Vin Net-_X1-Pad4_ Net-_R19-Pad2_ Net-_U6-Pad7_ +VCC ? lm_741
U6  Net-_U6-Pad1_ Net-_U6-Pad2_ Net-_U6-Pad3_ Net-_U6-Pad4_ Net-_U6-Pad5_ Net-_U6-Pad6_ Net-_U6-Pad7_ Net-_U6-Pad8_ Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ adc_bridge_8
v3  Vref GND 8
v5  GND Net-_X1-Pad4_ 15
R9  Net-_R9-Pad1_ out2 1k
R10  Net-_R10-Pad1_ out1 1k
R11  Net-_R11-Pad1_ out0 1k
U8  Vref plot_v1
U2  Net-_U2-Pad1_ Net-_U2-Pad2_ Net-_U2-Pad3_ Net-_U2-Pad4_ Net-_U2-Pad5_ Net-_U2-Pad6_ Net-_U2-Pad7_ Net-_U2-Pad8_ Net-_U2-Pad9_ Net-_U2-Pad10_ Net-_U2-Pad11_ priority_encode_vanshika
R12  Net-_R12-Pad1_ Net-_R12-Pad2_ 1k
R13  Net-_R13-Pad1_ Net-_R13-Pad2_ 1k
R14  Net-_R14-Pad1_ Net-_R14-Pad2_ 1k
R15  Net-_R15-Pad1_ Net-_R15-Pad2_ 1k
R16  Net-_R16-Pad1_ Net-_R16-Pad2_ 1k
R19  Net-_R19-Pad1_ Net-_R19-Pad2_ 1k
R17  Net-_R17-Pad1_ Net-_R17-Pad2_ 1k
R18  Net-_R18-Pad1_ Net-_R18-Pad2_ 1k

.end
